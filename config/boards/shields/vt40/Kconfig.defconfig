## config/boards/shields/vt40/Kconfig.defconfig
```kconfig
if SHIELD_VT40

config ZMK_KEYBOARD_NAME
    default "vt40"

config I2C
	default y

config GPIO_MCP23017
	default y

endif
```
